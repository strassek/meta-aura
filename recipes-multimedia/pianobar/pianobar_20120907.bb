require pianobar.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=7f7d65c519eee701c4884152c5d9fddc"

PR = "${INC_PR}.0"

SRCREV = "67badcc47bcada695d8cd19c061ee4801f8bfc18"

S = "${WORKDIR}/git"
