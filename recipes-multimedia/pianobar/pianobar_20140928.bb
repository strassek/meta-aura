require pianobar.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=cfeb8ae0065c00f1bf4f5a963872e934"

PR = "${INC_PR}.0"

SRCREV = "5b9e0d954c362314f18bd4348f4902073c69fc7f"

S = "${WORKDIR}/git"
